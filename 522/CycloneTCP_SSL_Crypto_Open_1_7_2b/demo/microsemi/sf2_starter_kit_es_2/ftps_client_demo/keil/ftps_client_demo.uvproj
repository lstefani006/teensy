# Keil uVision project ftps_client_demo.uvproj, settings and files
target ftps_client_demo_flash (ARM-ADS)
  device: M2S050 Microsemi
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x0-0x3FFFF) CLOCK(20000000) CPUTYPE("Cortex-M3")
  output: ftps_client_demo_flash
  c flags: Optim=1
  c define: M2S050 USE_SF2_STARTER_KIT_ES_2 NDEBUG
  c include: ..\src;..\..\..\..\common\cmsis\include;..\..\..\..\common\microsemi\devices\m2sxxx;..\..\..\..\common\microsemi\devices\m2sxxx\cmsis;..\..\..\..\common\microsemi\devices\m2sxxx\drivers;..\..\..\..\common\microsemi\boards\sf2_starter_kit_es_2;..\..\..\..\common\freertos\include;..\..\..\..\common\freertos\portable\rvds\arm_cm3;..\..\..\..\..\common;..\..\..\..\..\cyclone_tcp;..\..\..\..\..\cyclone_ssl;..\..\..\..\..\cyclone_crypto
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\m2sxxx_flash.sct
  group Demo Sources
    ./: startup_m2sxxx.s retarget.c
    ../src/: system_m2sxxx.c sys_config.c main.c debug.c
  group Demo Headers
    ../src/: sys_config.h sys_config_mss_clocks.h sys_config_mddr_define.h os_port_config.h net_config.h tls_config.h crypto_config.h FreeRTOSConfig.h
  group Common Sources
    ../../../../../common/: endian.c os_port_freertos.c date_time.c str.c
  group Common Headers
    ../../../../../common/: endian.h os_port.h os_port_freertos.h date_time.h str.h error.h debug.h
  group CycloneTCP Sources
    ../../../../../cyclone_tcp/core/: net.c net_mem.c nic.c ethernet.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c bsd_socket.c raw_socket.c
    ../../../../../cyclone_tcp/drivers/: m2sxxx_eth.c ksz8051.c
    ../../../../../cyclone_tcp/ipv4/: arp.c ipv4.c ipv4_frag.c icmp.c igmp.c
    ../../../../../cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c ipv6_misc.c ipv6_pmtu.c icmpv6.c mld.c ndp.c ndp_cache.c ndp_misc.c slaac.c
    ../../../../../cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_common.c
    ../../../../../cyclone_tcp/netbios/: nbns_client.c nbns_responder.c nbns_common.c
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_common.c dhcp_debug.c
    ../../../../../cyclone_tcp/ftp/: ftp_client.c
  group CycloneTCP Headers
    ../../../../../cyclone_tcp/core/: net.h net_mem.h nic.h ethernet.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h bsd_socket.h raw_socket.h
    ../../../../../cyclone_tcp/drivers/: m2sxxx_eth.h ksz8051.h
    ../../../../../cyclone_tcp/ipv4/: arp.h ipv4.h ipv4_frag.h icmp.h igmp.h
    ../../../../../cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h ipv6_misc.h ipv6_pmtu.h icmpv6.h mld.h ndp.h ndp_cache.h ndp_misc.h slaac.h
    ../../../../../cyclone_tcp/dns/: dns_cache.h dns_client.h dns_common.h dns_debug.h
    ../../../../../cyclone_tcp/mdns/: mdns_client.h mdns_responder.h mdns_common.h
    ../../../../../cyclone_tcp/netbios/: nbns_client.h nbns_responder.h nbns_common.h
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.h dhcp_common.h dhcp_debug.h
    ../../../../../cyclone_tcp/ftp/: ftp_client.h
  group CycloneSSL Sources
    ../../../../../cyclone_ssl/: tls.c tls_cipher_suites.c tls_client.c tls_server.c tls_common.c tls_record.c tls_io.c tls_misc.c tls_cache.c ssl_common.c
  group CycloneSSL Headers
    ../../../../../cyclone_ssl/: tls.h tls_cipher_suites.h tls_client.h tls_server.h tls_common.h tls_record.h tls_io.h tls_cache.h tls_misc.h ssl_common.h
  group CycloneCrypto Sources
    ../../../../../cyclone_crypto/: base64.c md2.c md4.c md5.c ripemd128.c ripemd160.c sha1.c sha224.c sha256.c sha384.c sha512.c sha512_224.c sha512_256.c tiger.c whirlpool.c hmac.c rc4.c rc6.c idea.c des.c des3.c aes.c camellia.c seed.c aria.c cipher_mode_ecb.c cipher_mode_cbc.c cipher_mode_cfb.c cipher_mode_ofb.c cipher_mode_ctr.c cipher_mode_ccm.c cipher_mode_gcm.c dh.c rsa.c dsa.c ec.c ec_curves.c ecdh.c ecdsa.c pkcs5.c mpi.c asn1.c oid.c x509.c pem.c yarrow.c
  group CycloneCrypto Headers
    ../../../../../cyclone_crypto/: crypto.h base64.h md2.h md4.h md5.h ripemd128.h ripemd160.h sha1.h sha224.h sha256.h sha384.h sha512.h sha512_224.h sha512_256.h tiger.h whirlpool.h hmac.h rc4.h rc6.h idea.h des.h des3.h aes.h camellia.h seed.h aria.h cipher_mode_ecb.h cipher_mode_cbc.h cipher_mode_cfb.h cipher_mode_ofb.h cipher_mode_ctr.h cipher_mode_ccm.h cipher_mode_gcm.h dh.h rsa.h dsa.h ec.h ec_curves.h ecdh.h ecdsa.h pkcs5.h mpi.h asn1.h oid.h x509.h pem.h yarrow.h
  group FreeRTOS Sources
    ../../../../common/freertos/portable/rvds/arm_cm3/: port.c
    ../../../../common/freertos/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../common/freertos/portable/memmang/: heap_3.c
  group FreeRTOS Headers
    ../../../../common/freertos/portable/rvds/arm_cm3/: portmacro.h
    ../../../../common/freertos/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group M2Sxxx MSS Drivers Sources
    ../../../../common/microsemi/devices/m2sxxx/drivers/mss_gpio/: mss_gpio.c
    ../../../../common/microsemi/devices/m2sxxx/drivers/mss_uart/: mss_uart.c
    ../../../../common/microsemi/devices/m2sxxx/drivers/mss_spi/: mss_spi.c
  group M2Sxxx MSS Drivers Headers
    ../../../../common/microsemi/devices/m2sxxx/drivers/mss_gpio/: mss_gpio.h
    ../../../../common/microsemi/devices/m2sxxx/drivers/mss_uart/: mss_uart.h
    ../../../../common/microsemi/devices/m2sxxx/drivers/mss_spi/: mss_spi.h
target ftps_client_demo_sram (ARM-ADS)
  device: M2S050 Microsemi
  cpu: as above
  output: ftps_client_demo_sram
  c flags: Optim=1
  c define: M2S050 USE_SF2_STARTER_KIT_ES_2 NDEBUG
  c include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\m2sxxx_sram.sct
