# IAR project web_server_demo.ewp, settings and files
configuration DDRAM (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMA5D27 Atmel SAMA5D27
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: CONFIG_SOC_SAMA5D27; CONFIG_BOARD_SAMA5D2_XPLAINED; CONFIG_SOC_SAMA5; CONFIG_SOC_SAMA5D2; CONFIG_SOC_SAMA5D27; CONFIG_BOARD_SAMA5D2_XPLAINED; CONFIG_HAVE_FLEXCOM; CONFIG_HAVE_PIO4; CONFIG_HAVE_QSPI; CONFIG_HAVE_MCAN; CONFIG_HAVE_SDMMC; CONFIG_HAVE_PMIC_ACT8945A; CONFIG_HAVE_USART_FIFO; CONFIG_HAVE_USART_LIN; CONFIG_HAVE_SPI_FIFO; CONFIG_HAVE_TWI_FIFO; CONFIG_HAVE_GMAC_QUEUES; CONFIG_HAVE_DDR3; CONFIG_HAVE_DDR3_SELFREFRESH; CONFIG_HAVE_TWI_ALTERNATE_CMD; CONFIG_HAVE_ADC_SETTLING_TIME; CONFIG_HAVE_ADC_INPUT_OFFSET; CONFIG_HAVE_ADC_INPUT_GAIN; CONFIG_HAVE_ADC_SEQ_R2; CONFIG_HAVE_PMC_FAST_STARTUP; CONFIG_HAVE_PMC_GENERATED_CLOCKS; CONFIG_HAVE_PMC_AUDIO_CLOCK; CONFIG_HAVE_PWM_EXTERNAL_TRIGGER
  ICCARM.CCIncludePath2: ..\src; ..\..\..\..\common\atmel\devices\sama5d2x; ..\..\..\..\common\atmel\devices\sama5d2x\drivers; ..\..\..\..\common\atmel\devices\sama5d2x\drivers\cortex-a; ..\..\..\..\common\atmel\devices\sama5d2x\utils; ..\..\..\..\common\atmel\boards\sama5d2_xplained_ultra; ..\..\..\..\common\freertos\include; ..\..\..\..\common\freertos\portable\iar\arm_ca5_no_gic; ..\..\..\..\..\common; ..\..\..\..\..\cyclone_tcp; ..\..\..\..\..\cyclone_ssl; ..\..\..\..\..\cyclone_crypto
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: web_server_demo.srec
  prebuild: ..\..\..\..\..\utils\ResourceCompiler\bin\rc.exe ..\resources\ ..\src\res.c
  ILINK.IlinkOutputFile: web_server_demo.out
  ILINK.IlinkIcfFile: sama5d2x_ddram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration SRAM (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: sama5d2x_sram.icf
  group Demo Sources
    ./: cstartup.s
    ../src/: main.c freertos_tick_config.c freertos_irq_handler.c debug.c res.c
  group Demo Headers
    ../src/: os_port_config.h net_config.h tls_config.h crypto_config.h FreeRTOSConfig.h
  group Common Sources
    ../../../../../common/: endian.c os_port_freertos.c date_time.c str.c path.c resource_manager.c
  group Common Headers
    ../../../../../common/: endian.h os_port.h os_port_freertos.h date_time.h str.h path.h resource_manager.h error.h debug.h
  group CycloneTCP Sources
    ../../../../../cyclone_tcp/core/: net.c net_mem.c nic.c ethernet.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c bsd_socket.c raw_socket.c
    ../../../../../cyclone_tcp/drivers/: sama5d2_eth.c ksz8081.c
    ../../../../../cyclone_tcp/ipv4/: arp.c ipv4.c ipv4_frag.c icmp.c igmp.c
    ../../../../../cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c ipv6_misc.c ipv6_pmtu.c icmpv6.c mld.c ndp.c ndp_cache.c ndp_misc.c slaac.c
    ../../../../../cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_common.c
    ../../../../../cyclone_tcp/netbios/: nbns_client.c nbns_responder.c nbns_common.c
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_common.c dhcp_debug.c
    ../../../../../cyclone_tcp/http/: http_server.c http_server_auth.c http_server_misc.c mime.c ssi.c
    ../../../../../cyclone_tcp/smtp/: smtp_client.c
  group CycloneTCP Headers
    ../../../../../cyclone_tcp/core/: net.h net_mem.h nic.h ethernet.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h bsd_socket.h raw_socket.h
    ../../../../../cyclone_tcp/drivers/: sama5d2_eth.h ksz8081.h
    ../../../../../cyclone_tcp/ipv4/: arp.h ipv4.h ipv4_frag.h icmp.h igmp.h
    ../../../../../cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h ipv6_misc.h ipv6_pmtu.h icmpv6.h mld.h ndp.h ndp_cache.h ndp_misc.h slaac.h
    ../../../../../cyclone_tcp/dns/: dns_cache.h dns_client.h dns_common.h dns_debug.h
    ../../../../../cyclone_tcp/mdns/: mdns_client.h mdns_responder.h mdns_common.h
    ../../../../../cyclone_tcp/netbios/: nbns_client.h nbns_responder.h nbns_common.h
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.h dhcp_common.h dhcp_debug.h
    ../../../../../cyclone_tcp/http/: http_server.h http_server_auth.h http_server_misc.h mime.h ssi.h
    ../../../../../cyclone_tcp/smtp/: smtp_client.h
  group CycloneSSL Sources
    ../../../../../cyclone_ssl/: tls.c tls_cipher_suites.c tls_client.c tls_server.c tls_common.c tls_record.c tls_io.c tls_misc.c tls_cache.c ssl_common.c
  group CycloneSSL Headers
    ../../../../../cyclone_ssl/: tls.h tls_cipher_suites.h tls_client.h tls_server.h tls_common.h tls_record.h tls_io.h tls_cache.h tls_misc.h ssl_common.h
  group CycloneCrypto Sources
    ../../../../../cyclone_crypto/: base64.c md2.c md4.c md5.c ripemd128.c ripemd160.c sha1.c sha224.c sha256.c sha384.c sha512.c sha512_224.c sha512_256.c tiger.c whirlpool.c hmac.c rc4.c rc6.c idea.c des.c des3.c aes.c camellia.c seed.c aria.c cipher_mode_ecb.c cipher_mode_cbc.c cipher_mode_cfb.c cipher_mode_ofb.c cipher_mode_ctr.c cipher_mode_ccm.c cipher_mode_gcm.c dh.c rsa.c dsa.c ec.c ec_curves.c ecdh.c ecdsa.c pkcs5.c mpi.c asn1.c oid.c x509.c pem.c yarrow.c
  group CycloneCrypto Headers
    ../../../../../cyclone_crypto/: crypto.h base64.h md2.h md4.h md5.h ripemd128.h ripemd160.h sha1.h sha224.h sha256.h sha384.h sha512.h sha512_224.h sha512_256.h tiger.h whirlpool.h hmac.h rc4.h rc6.h idea.h des.h des3.h aes.h camellia.h seed.h aria.h cipher_mode_ecb.h cipher_mode_cbc.h cipher_mode_cfb.h cipher_mode_ofb.h cipher_mode_ctr.h cipher_mode_ccm.h cipher_mode_gcm.h dh.h rsa.h dsa.h ec.h ec_curves.h ecdh.h ecdsa.h pkcs5.h mpi.h asn1.h oid.h x509.h pem.h yarrow.h
  group FreeRTOS Sources
    ../../../../common/freertos/portable/iar/arm_ca5_no_gic/: port.c portasm.s
    ../../../../common/freertos/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../common/freertos/portable/memmang/: heap_3.c
  group FreeRTOS Headers
    ../../../../common/freertos/portable/iar/arm_ca5_no_gic/: portmacro.h portasm.h
    ../../../../common/freertos/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group SAMA5D2 Drivers Sources
    ../../../../common/atmel/devices/sama5d2x/drivers/cortex-a/: cortexa5_interrupts.c cp15.c cp15_asm_iar.s cp15_pmu.c cpsr_iar.s mmu.c
    ../../../../common/atmel/devices/sama5d2x/drivers/peripherals/: acc.c adc.c aic.c classd.c flexcom.c hsmc.c icm.c isc.c l2cc.c matrix.c mcan.c mpddrc.c pdmic.c pio4.c pit.c pmc.c pmecc.c pmecc_gallois_field_512.c pmecc_gallois_field_1024.c pwmc.c qspi.c rstc.c rtc.c secumod.c sfc.c sfrbu.c sha.c shdwc.c spi.c spid.c ssc.c tc.c tdes.c trng.c twi.c twid.c uart.c usart.c usart_iso7816_4.c wdt.c xdmac.c xdmad.c
  group SAMA5D2 Drivers Headers
    ../../../../common/atmel/devices/sama5d2x/drivers/cortex-a/: cortexa5_interrupts.h cp15.h cp15_pmu.h cpsr.h mmu.h
    ../../../../common/atmel/devices/sama5d2x/drivers/peripherals/: acc.h adc.h aic.h classd.h flexcom.h hsmc.h icm.h isc.h l2cc.h matrix.h mcan.h mpddrc.h pdmic.h pio.h pio4.h pit.h pmc.h pmecc.h pmecc_gallois_field_512.h pmecc_gallois_field_1024.h pwmc.h qspi.h rstc.h rtc.h secumod.h sfc.h sfrbu.h sha.h shdwc.h spi.h spid.h ssc.h tc.h tdes.h trng.h twi.h twid.h uart.h usart.h usart_iso7816_4.h usart_lin.h usartd.h wdt.h xdmac.h xdmad.h
  group SAMA5D2 Utils Sources
    ../../../../common/atmel/devices/sama5d2x/: chip.c
    ../../../../common/atmel/devices/sama5d2x/utils/: mutex.c mutex_iar.s timer.c trace.c
  group SAMA5D2 Utils Headers
    ../../../../common/atmel/devices/sama5d2x/: chip.h
    ../../../../common/atmel/devices/sama5d2x/utils/: compiler.h intmath.h io.h mutex.h timer.h trace.h
  group SAMA5D2-Xplained-Ultra Sources
    ../../../../common/atmel/boards/sama5d2_xplained_ultra/: board_lowlevel.c board_support.c act8945a.c
  group SAMA5D2-Xplained-Ultra Headers
    ../../../../common/atmel/boards/sama5d2_xplained_ultra/: board.h board_sama5d2-xplained.h board_lowlevel.h board_support.h act8945a.h
